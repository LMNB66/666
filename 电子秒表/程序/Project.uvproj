# Keil uVision project Project.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c lcd1602.c lcd1602.h Delay.h Delay.c Interrupt.c Interrupt.h function.c function.h Key.c Key.h
