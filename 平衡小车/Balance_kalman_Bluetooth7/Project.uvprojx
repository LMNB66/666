# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_LD,__USE_C99_MATH
  c misc: --C99
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\Drive\kalman;.\Drive\MPU6050;.\Drive\oled;.\Drive\pwm;.\Drive\tim;.\Drive\pid
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group DRIVE
    ./Drive/kalman/: kalman.c
    ./Drive/MPU6050/: mpu6050.c mpuiic.c
    ./Drive/oled/: oled.c
    ./Drive/pwm/: pwm.c
    ./Drive/tim/: tim.c
    ./Drive/pid/: pid.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
